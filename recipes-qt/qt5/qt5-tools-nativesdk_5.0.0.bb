require qt5-native.inc
require qt5-tools-nativesdk.inc

PR = "${INC_PR}.0"
DEFAULT_PREFERENCE = "-1"
