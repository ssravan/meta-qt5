require qt-${PV}.inc
require nativesdk-qt5-tools.inc

PR = "${INC_PR}.0"
DEFAULT_PREFERENCE = "-1"
